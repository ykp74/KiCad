# Repository ykp74/KiCad (continued)

## KiCad design project4/project4.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9: 0.1uF; C_Disc_D6.0mm_W2.5mm_P5.00mm
C10: 10uF; CP_Radial_D5.0mm_P2.50mm
CE1: Card_Edge_Connector_MSX; card_edge_connector_MSX
J1, J2, J3, J4, J5: Conn_02x03; PinHeader_2x03_P2.54mm_Vertical
J6: Conn_02x02; PinHeader_2x02_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1, U2, U3, U4: SST27ST020; DIP-32_W15.24mm_Socket
U5: 74LS139; DIP-16_W7.62mm_Socket
U6: 74LS32; DIP-14_W7.62mm_Socket
U7: 74LS00; DIP-14_W7.62mm_Socket
U8, U9: 74LS670; DIP-16_W7.62mm_Socket

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, CE1.45 (+5V), CE1.47 (+5V), J2.5, J3.3, J3.5, U1.1 (VPP), U1.31 (~PGM), U1.32 (VCC), U2.1 (VPP), U2.31 (~PGM), U2.32 (VCC), U3.1 (VPP), U3.31 (~PGM), U3.32 (VCC), U4.1 (VPP), U4.31 (~PGM), U4.32 (VCC), U5.16 (VCC), U6.14 (VCC), U7.14 (VCC), U8.16 (VCC), U9.16 (VCC)
/A0: CE1.28 (A0), J5.5, U1.12 (A0), U2.12 (A0), U3.12 (A0), U4.12 (A0)
/A1: CE1.27 (A1), J4.5, U1.11 (A1), U2.11 (A1), U3.11 (A1), U4.11 (A1)
/A2: CE1.30 (A2), U1.10 (A2), U2.10 (A2), U3.10 (A2), U4.10 (A2)
/A3: CE1.29 (A3), U1.9 (A3), U2.9 (A3), U3.9 (A3), U4.9 (A3)
/A4: CE1.32 (A4), U1.8 (A4), U2.8 (A4), U3.8 (A4), U4.8 (A4)
/A5: CE1.31 (A5), U1.7 (A5), U2.7 (A5), U3.7 (A5), U4.7 (A5)
/A6: CE1.22 (A6), U1.6 (A6), U2.6 (A6), U3.6 (A6), U4.6 (A6)
/A7: CE1.21 (A7), U1.5 (A7), U2.5 (A7), U3.5 (A7), U4.5 (A7)
/A8: CE1.24 (A8), U1.27 (A8), U2.27 (A8), U3.27 (A8), U4.27 (A8)
/A9: CE1.17 (A9), U1.26 (A9), U2.26 (A9), U3.26 (A9), U4.26 (A9)
/A10: CE1.20 (A10), U1.23 (A10), U2.23 (A10), U3.23 (A10), U4.23 (A10)
/A11: CE1.19 (A11), J1.3, J5.1, U1.25 (A11), U2.25 (A11), U3.25 (A11), U4.25 (A11)
/A12: CE1.23 (A12), J1.5, J2.3, J4.1, U1.4 (A12), U2.4 (A12), U3.4 (A12), U4.4 (A12)
/A13: CE1.26 (A13), J2.1, J5.3, U6.13, U8.4 (Rb), U9.4 (Rb)
/A14: CE1.25 (A14), J3.1
/A15: CE1.18 (A15), J1.1, J4.3, U6.12, U8.5 (Ra), U9.5 (Ra)
/D0: CE1.34 (D0), U1.13 (D0), U2.13 (D0), U3.13 (D0), U4.13 (D0), U8.15 (D1)
/D1: CE1.33 (D1), U1.14 (D1), U2.14 (D1), U3.14 (D1), U4.14 (D1), U8.1 (D2)
/D2: CE1.36 (D2), U1.15 (D2), U2.15 (D2), U3.15 (D2), U4.15 (D2), U8.2 (D3)
/D3: CE1.35 (D3), U1.17 (D3), U2.17 (D3), U3.17 (D3), U4.17 (D3), U8.3 (D4)
/D4: CE1.38 (D4), U1.18 (D4), U2.18 (D4), U3.18 (D4), U4.18 (D4), U9.15 (D1)
/D5: CE1.37 (D5), U1.19 (D5), U2.19 (D5), U3.19 (D5), U4.19 (D5), U9.1 (D2)
/D6: CE1.40 (D6), U1.20 (D6), U2.20 (D6), U3.20 (D6), U4.20 (D6), U9.2 (D3)
/D7: CE1.39 (D7), U1.21 (D7), U2.21 (D7), U3.21 (D7), U4.21 (D7)
/MA13: R7.2, U1.28 (A13), U2.28 (A13), U3.28 (A13), U4.28 (A13), U8.10 (Q1)
/MA14: R6.2, U1.29 (A14), U2.29 (A14), U3.29 (A14), U4.29 (A14), U8.9 (Q2)
/MA15: R4.2, U1.3 (A15), U2.3 (A15), U3.3 (A15), U4.3 (A15), U8.7 (Q3)
/MA16: R2.2, U1.2 (A16), U2.2 (A16), U3.2 (A16), U4.2 (A16), U8.6 (Q4)
/MA17: R3.2, U1.30 (A17), U2.30 (A17), U3.30 (A17), U4.30 (A17), U9.10 (Q1)
/ROM_CE1: U1.22 (~CE), U5.4 (O0)
/ROM_CE2: U2.22 (~CE), U5.5 (O1)
/ROM_CE3: U3.22 (~CE), U5.6 (O2)
/ROM_CE4: U4.22 (~CE), U5.7 (O3)
//Er: J6.2, J6.4, U8.11 (~Er), U9.11 (~Er)
//RD: CE1.14 (~RD), U1.24 (~OE), U2.24 (~OE), U3.24 (~OE), U4.24 (~OE)
//SLTSL: CE1.4 (~STLSL), U5.1 (E), U6.2
//WR: CE1.13 (~WR), U6.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, CE1.41 (GND), CE1.43 (GND), J6.3, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, U1.16 (GND), U2.16 (GND), U3.16 (GND), U4.16 (GND), U5.8 (GND), U6.7 (GND), U7.7 (GND), U8.8 (GND), U9.8 (GND)
unnamed: J1.2, J1.4, J1.6, U6.9
unnamed: J2.2, J2.4, J2.6, U7.1
unnamed: J3.2, J3.4, J3.6, U7.2
unnamed: J4.2, J4.4, J4.6, U8.14 (Wa), U9.14 (Wa)
unnamed: J5.2, J5.4, J5.6, U8.13 (Wb), U9.13 (Wb)
unnamed: J6.1, U7.11
unnamed: R1.2, U5.2 (A0), U9.9 (Q2)
unnamed: R5.2, U5.3 (A1), U9.7 (Q3)
unnamed: U6.3, U6.5
unnamed: U6.4, U6.8
unnamed: U6.10, U7.3
unnamed: U6.11, U7.12, U7.13
unnamed: U6.6, U8.12 (~Ew), U9.12 (~Ew)

Notes on the sheet:
ASCII 8K KONAMI 8K SCREEN 8K
ASCII 8K KONAMI5 8K KONAMI4 8K
KONAMI4 ONLY
회로도 편집기

Board: 2 copper layers, 100.8 x 98.2 mm, 33 parts (0 on the bottom side), 52 nets.

## KiCad design ykp74/ykp74.kicad_pcb

Parts:
C1, C2, C3, C4, C6, C7, C8, C9: 100n; C_Disc_D6.0mm_W2.5mm_P5.00mm
C5: 10uf; CP_Radial_D5.0mm_P2.50mm
CE1: Card_Edge_Connector_MSX; card_edge_connector_MSX
R1, R2, R3, R4: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1, U2, U3, U4: 27C256; DIP-28_W15.24mm_Socket
U5: 74LS139; DIP-16_W7.62mm_Socket
U6: 74LS32; DIP-14_W7.62mm_Socket
U7: 74LS04; DIP-14_W7.62mm_Socket
U8: 74LS670; DIP-16_W7.62mm_Socket

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, CE1.45 (+5V), CE1.47 (+5V), U1.1 (VPP), U1.28 (VCC), U2.1 (VPP), U2.28 (VCC), U3.1 (VPP), U3.28 (VCC), U4.1 (VPP), U4.28 (VCC), U5.16 (VCC), U6.14 (VCC), U7.14 (VCC), U8.16 (VCC)
/A0: CE1.28 (A0), U1.10 (A0), U2.10 (A0), U3.10 (A0), U4.10 (A0)
/A1: CE1.27 (A1), U1.9 (A1), U2.9 (A1), U3.9 (A1), U4.9 (A1)
/A2: CE1.30 (A2), U1.8 (A2), U2.8 (A2), U3.8 (A2), U4.8 (A2)
/A3: CE1.29 (A3), U1.7 (A3), U2.7 (A3), U3.7 (A3), U4.7 (A3)
/A4: CE1.32 (A4), U1.6 (A4), U2.6 (A4), U3.6 (A4), U4.6 (A4)
/A5: CE1.31 (A5), U1.5 (A5), U2.5 (A5), U3.5 (A5), U4.5 (A5)
/A6: CE1.22 (A6), U1.4 (A6), U2.4 (A6), U3.4 (A6), U4.4 (A6)
/A7: CE1.21 (A7), U1.3 (A7), U2.3 (A7), U3.3 (A7), U4.3 (A7)
/A8: CE1.24 (A8), U1.25 (A8), U2.25 (A8), U3.25 (A8), U4.25 (A8)
/A9: CE1.17 (A9), U1.24 (A9), U2.24 (A9), U3.24 (A9), U4.24 (A9)
/A10: CE1.20 (A10), U1.21 (A10), U2.21 (A10), U3.21 (A10), U4.21 (A10)
/A11: CE1.19 (A11), U1.23 (A11), U2.23 (A11), U3.23 (A11), U4.23 (A11)
/A12: CE1.23 (A12), U1.2 (A12), U2.2 (A12), U3.2 (A12), U4.2 (A12)
/A13: CE1.26 (A13), U6.5, U8.4 (Rb), U8.13 (Wb)
/A15: CE1.18 (A15), U6.4, U8.5 (Ra), U8.14 (Wa)
/D0: CE1.34 (D0), U1.11 (D0), U2.11 (D0), U3.11 (D0), U4.11 (D0), U8.3 (D4)
/D1: CE1.33 (D1), U1.12 (D1), U2.12 (D1), U3.12 (D1), U4.12 (D1), U8.2 (D3)
/D2: CE1.36 (D2), U1.13 (D2), U2.13 (D2), U3.13 (D2), U4.13 (D2), U8.1 (D2)
/D3: CE1.35 (D3), U1.15 (D3), U2.15 (D3), U3.15 (D3), U4.15 (D3), U8.15 (D1)
/D4: CE1.38 (D4), U1.16 (D4), U2.16 (D4), U3.16 (D4), U4.16 (D4)
/D5: CE1.37 (D5), U1.17 (D5), U2.17 (D5), U3.17 (D5), U4.17 (D5)
/D6: CE1.40 (D6), U1.18 (D6), U2.18 (D6), U3.18 (D6), U4.18 (D6)
/D7: CE1.39 (D7), U1.19 (D7), U2.19 (D7), U3.19 (D7), U4.19 (D7)
/MA13: R2.1, U1.26 (A13), U2.26 (A13), U3.26 (A13), U4.26 (A13), U8.6 (Q4)
/MA14: R1.2, U1.27 (A14), U2.27 (A14), U3.27 (A14), U4.27 (A14), U8.7 (Q3)
/ROM_CE1: U1.20 (~CE), U5.4 (O0)
/ROM_CE2: U2.20 (~CE), U5.5 (O1)
/ROM_CE3: U3.20 (~CE), U5.6 (O2)
/ROM_CE4: U4.20 (~CE), U5.7 (O3)
//RD: CE1.14 (~RD), U1.22 (~OE), U2.22 (~OE), U3.22 (~OE), U4.22 (~OE)
//SLTSL: CE1.4 (~STLSL), U5.1 (E), U6.2
//WR: CE1.13 (~WR), U6.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, CE1.41 (GND), CE1.43 (GND), R1.1, R2.2, R3.1, R4.2, U1.14 (GND), U2.14 (GND), U3.14 (GND), U4.14 (GND), U5.8 (GND), U6.7 (GND), U7.7 (GND), U8.8 (GND)
unnamed: R4.1, U5.2 (A0), U8.9 (Q2)
unnamed: R3.2, U5.3 (A1), U8.10 (Q1)
unnamed: U6.6, U7.1
unnamed: U7.2, U8.11 (~Er)
unnamed: U6.3, U8.12 (~Ew)

Board: 2 copper layers, 100.7 x 76.7 mm, 22 parts (0 on the bottom side), 39 nets.

## KiCad design project3/project3.kicad_pcb

Parts:
C1, C2, C3, C5, C6, C7: 0.1uF; C_Disc_D6.0mm_W2.5mm_P5.00mm
C4: 10uF; CP_Radial_D5.0mm_P2.50mm
CE1: Card_Edge_Connector_MSX; card_edge_connector_MSX
R1, R2, R3, R4, R5, R6: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1, U2: SST27ST020; DIP-32_W15.24mm_Socket
U3: 74LS02; DIP-14_W7.62mm_Socket
U4, U6: 74LS670; DIP-16_W7.62mm_Socket
U5: 74LS139; DIP-16_W7.62mm_Socket

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, CE1.45 (+5V), CE1.47 (+5V), U1.1 (VPP), U1.31 (~PGM), U1.32 (VCC), U2.1 (VPP), U2.31 (~PGM), U2.32 (VCC), U3.14 (VCC), U4.16 (VCC), U5.16 (VCC), U6.16 (VCC)
/A0: CE1.28 (A0), U1.12 (A0), U2.12 (A0)
/A1: CE1.27 (A1), U1.11 (A1), U2.11 (A1)
/A2: CE1.30 (A2), U1.10 (A2), U2.10 (A2)
/A3: CE1.29 (A3), U1.9 (A3), U2.9 (A3)
/A4: CE1.32 (A4), U1.8 (A4), U2.8 (A4)
/A5: CE1.31 (A5), U1.7 (A5), U2.7 (A5)
/A6: CE1.22 (A6), U1.6 (A6), U2.6 (A6)
/A7: CE1.21 (A7), U1.5 (A7), U2.5 (A7)
/A8: CE1.24 (A8), U1.27 (A8), U2.27 (A8)
/A9: CE1.17 (A9), U1.26 (A9), U2.26 (A9)
/A10: CE1.20 (A10), U1.23 (A10), U2.23 (A10)
/A11: CE1.19 (A11), U1.25 (A11), U2.25 (A11)
/A12: CE1.23 (A12), U1.4 (A12), U2.4 (A12)
/A13: CE1.26 (A13), U3.9, U4.4 (Rb), U4.13 (Wb), U6.4 (Rb), U6.13 (Wb)
/A15: CE1.18 (A15), U3.8, U4.5 (Ra), U4.14 (Wa), U6.5 (Ra), U6.14 (Wa)
/D0: CE1.34 (D0), U1.13 (D0), U2.13 (D0), U4.3 (D4)
/D1: CE1.33 (D1), U1.14 (D1), U2.14 (D1), U4.2 (D3)
/D2: CE1.36 (D2), U1.15 (D2), U2.15 (D2), U4.1 (D2)
/D3: CE1.35 (D3), U1.17 (D3), U2.17 (D3), U4.15 (D1)
/D4: CE1.38 (D4), U1.18 (D4), U2.18 (D4), U6.15 (D1)
/D5: CE1.37 (D5), U1.19 (D5), U2.19 (D5), U6.1 (D2)
/D6: CE1.40 (D6), U1.20 (D6), U2.20 (D6)
/D7: CE1.39 (D7), U1.21 (D7), U2.21 (D7)
/MA13: R1.2, U1.28 (A13), U2.28 (A13), U4.6 (Q4)
/MA14: R2.2, U1.29 (A14), U2.29 (A14), U4.7 (Q3)
/MA15: R3.2, U1.3 (A15), U2.3 (A15), U4.9 (Q2)
/MA16: R4.2, U1.2 (A16), U2.2 (A16), U4.10 (Q1)
/MA17: R6.2, U1.30 (A17), U2.30 (A17), U6.10 (Q1)
/ROM_CE1: U1.22 (~CE), U5.4 (O0)
/ROM_CE2: U2.22 (~CE), U5.5 (O1)
//RD: CE1.14 (~RD), U1.24 (~OE), U2.24 (~OE)
//SLTSL: CE1.4 (~STLSL), U3.3, U5.1 (E)
//WR: CE1.13 (~WR), U3.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, CE1.41 (GND), CE1.43 (GND), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, U1.16 (GND), U2.16 (GND), U3.7 (GND), U4.8 (GND), U5.3 (A1), U5.8 (GND), U6.8 (GND)
unnamed: U3.1, U3.5, U3.6
unnamed: U3.10, U4.11 (~Er), U6.11 (~Er)
unnamed: U3.4, U4.12 (~Ew), U6.12 (~Ew)
unnamed: R5.2, U5.2 (A0), U6.9 (Q2)

Board: 2 copper layers, 100.8 x 64.0 mm, 20 parts (0 on the bottom side), 39 nets.

## Commit log (part)

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2023-03-16 -off-by: ykp74 <ykp7409@gmail.com>
2023-03-19 Build Geber Files
2023-03-28 Created 4Mega ROM PCB - Change DIP32 type FLASH ROM - Optimal Logic Mega Rom Mapper.
2023-03-29 Modify PCB design.
2023-03-30 Modify the PCB layout
2023-03-30 Added git ignor file
2023-03-30 Modified PCB some design Optimal layout.
2023-03-31 Build gerber files
2023-03-31 Modify PCB
2023-03-31 Modify gitignore file
2023-04-03 Change the Foot Print of Edge slot
2023-04-06 Created Project4 - Support various Mega Rom Mapper
2023-04-07 Created Project4 - Design to support ASCII 8Kb Mega ROM
2023-04-11 Modify project4
2023-04-12 Modify PCB4 by ykp74
2023-04-13 Modify PCB4
2023-04-16 Modified PCB 4
2023-04-18 Final
2023-04-18 Modify PCB4 final
2023-04-19 Added new project2-2
2023-04-20 modify PCB 2-2
2023-04-21 Modify PCB2-2
2023-04-25 Sync up files
2023-05-31 Modify .gitignore
2023-05-31 Modify
2023-05-31 Modify PCB file
2023-06-09 Final revision
2026-06-28 Added Mega Ram Card
    Signeod-off-by: ykp74 <ykp7409@gmail.com>

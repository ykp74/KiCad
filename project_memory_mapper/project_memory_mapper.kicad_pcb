# Repository ykp74/KiCad

## KiCad design project_memory_mapper/project_memory_mapper.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8: 0.1uF; C_Disc_D6.0mm_W2.5mm_P5.00mm
C9: 100uF; CP_Radial_D5.0mm_P2.50mm
CE1: Card_Edge_Connector_MSX; card_edge_connector_MSX
U1: 74LS30; DIP-14_W7.62mm_Socket
U2: 74LS139; DIP-16_W7.62mm_Socket
U3, U4: 74LS670; DIP-16_W7.62mm_Socket
U5, U6, U7, U8: CS18LV10245; DIP-32_W15.24mm_Socket

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, CE1.45 (+5V), CE1.47 (+5V), U1.11, U1.12, U1.14 (VCC), U2.16 (VCC), U3.16 (VCC), U4.16 (VCC), U5.30 (CE2), U5.32 (VCC), U6.30 (CE2), U6.32 (VCC), U7.30 (CE2), U7.32 (VCC), U8.30 (CE2), U8.32 (VCC)
/A0: CE1.28 (A0), U3.14 (Wa), U4.14 (Wa), U5.12 (A0), U6.12 (A0), U7.12 (A0), U8.12 (A0)
/A1: CE1.27 (A1), U3.13 (Wb), U4.13 (Wb), U5.11 (A1), U6.11 (A1), U7.11 (A1), U8.11 (A1)
/A2: CE1.30 (A2), U1.1, U5.10 (A2), U6.10 (A2), U7.10 (A2), U8.10 (A2)
/A3: CE1.29 (A3), U1.2, U5.9 (A3), U6.9 (A3), U7.9 (A3), U8.9 (A3)
/A4: CE1.32 (A4), U1.3, U5.8 (A4), U6.8 (A4), U7.8 (A4), U8.8 (A4)
/A5: CE1.31 (A5), U1.4, U5.7 (A5), U6.7 (A5), U7.7 (A5), U8.7 (A5)
/A6: CE1.22 (A6), U1.5, U5.6 (A6), U6.6 (A6), U7.6 (A6), U8.6 (A6)
/A7: CE1.21 (A7), U1.6, U5.5 (A7), U6.5 (A7), U7.5 (A7), U8.5 (A7)
/A8: CE1.24 (A8), U5.27 (A8), U6.27 (A8), U7.27 (A8), U8.27 (A8)
/A9: CE1.17 (A9), U5.26 (A9), U6.26 (A9), U7.26 (A9), U8.26 (A9)
/A10: CE1.20 (A10), U5.23 (A10), U6.23 (A10), U7.23 (A10), U8.23 (A10)
/A11: CE1.19 (A11), U5.25 (A11), U6.25 (A11), U7.25 (A11), U8.25 (A11)
/A12: CE1.23 (A12), U5.4 (A12), U6.4 (A12), U7.4 (A12), U8.4 (A12)
/A13: CE1.26 (A13), U5.28 (A13), U6.28 (A13), U7.28 (A13), U8.28 (A13)
/A14: CE1.25 (A14), U3.5 (Ra), U4.5 (Ra)
/A15: CE1.18 (A15), U3.4 (Rb), U4.4 (Rb)
/D0: CE1.34 (D0), U3.15 (D1), U5.13 (D0), U6.13 (D0), U7.13 (D0), U8.13 (D0)
/D1: CE1.33 (D1), U3.1 (D2), U5.14 (D1), U6.14 (D1), U7.14 (D1), U8.14 (D1)
/D2: CE1.36 (D2), U3.2 (D3), U5.15 (D2), U6.15 (D2), U7.15 (D2), U8.15 (D2)
/D3: CE1.35 (D3), U3.3 (D4), U5.17 (D3), U6.17 (D3), U7.17 (D3), U8.17 (D3)
/D4: CE1.38 (D4), U4.15 (D1), U5.18 (D4), U6.18 (D4), U7.18 (D4), U8.18 (D4)
/D5: CE1.37 (D5), U4.1 (D2), U5.19 (D5), U6.19 (D5), U7.19 (D5), U8.19 (D5)
/D6: CE1.40 (D6), U4.2 (D3), U5.20 (D6), U6.20 (D6), U7.20 (D6), U8.20 (D6)
/D7: CE1.39 (D7), U4.3 (D4), U5.21 (D7), U6.21 (D7), U7.21 (D7), U8.21 (D7)
/MA14: U3.10 (Q1), U5.3 (A14), U6.3 (A14), U7.3 (A14), U8.3 (A14)
/MA15: U3.9 (Q2), U5.31 (A15), U6.31 (A15), U7.31 (A15), U8.31 (A15)
/MA16: U3.7 (Q3), U5.2 (A16), U6.2 (A16), U7.2 (A16), U8.2 (A16)
/MA17: U2.2 (A0), U3.6 (Q4)
/MA18: U2.3 (A1), U4.10 (Q1)
/MA19: U4.9 (Q2)
/MA20: U4.7 (Q3)
/MA21: U4.6 (Q4)
/RAM_0: U2.4 (O0), U5.22 (~CE1)
/RAM_1: U2.5 (O1), U6.22 (~CE1)
/RAM_2: U2.6 (O2), U7.22 (~CE1)
/RAM_3: U2.7 (O3), U8.22 (~CE1)
//IORQ: CE1.11 (~IORQ), U2.13 (A1)
//RD: CE1.14 (~RD), U5.24 (~OE), U6.24 (~OE), U7.24 (~OE), U8.24 (~OE)
//STLSL: CE1.4 (~STLSL), U2.1 (E)
//WR: CE1.13 (~WR), U2.14 (A0), U5.29 (~WE), U6.29 (~WE), U7.29 (~WE), U8.29 (~WE)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, CE1.41 (GND), CE1.43 (GND), U1.7 (GND), U2.8 (GND), U3.8 (GND), U3.11 (~Er), U4.8 (GND), U4.11 (~Er), U5.16 (GND), U6.16 (GND), U7.16 (GND), U8.16 (GND)
unnamed: U1.8, U2.15 (E)
unnamed: U2.12 (O0), U3.12 (~Ew), U4.12 (~Ew)

Notes on the sheet:
회로도 편집기

Board: 2 copper layers, 100.7 x 77.2 mm, 18 parts (0 on the bottom side), 41 nets.

## KiCad design project_mega_ram/project_mega_ram.kicad_pcb

Parts:
C1, C2, C3, C5, C6, C7, C8, C9, C10, C11, C12, C13: 0.1uF; C_Disc_D6.0mm_W2.5mm_P5.00mm
C4: 100uF; CP_Radial_D5.0mm_P2.50mm
CE1: card_edge_connector_msx; card_edge_connector_MSX
RN1, RN2: R_Net 4.7K; R_Array_SIP5
U1, U3: 74LS670; DIP-16_W7.62mm_Socket
U2, U12: CS18LV10245; DIP-32_W15.24mm_Socket
U4, U5: 74LS157; DIP-16_W7.62mm_Socket
U6: 74LS08; DIP-14_W7.62mm_Socket
U7, U9: 74LS32; DIP-14_W7.62mm_Socket
U8: 74LS74; DIP-14_W7.62mm_Socket
U10: 74LS02; DIP-14_W7.62mm_Socket
U11: 74LS139; DIP-16_W7.62mm_Socket

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, CE1.45 (+5V), CE1.47 (+5V), U1.16 (VCC), U2.30 (CE2), U2.32 (VCC), U3.16 (VCC), U4.16 (VCC), U5.16 (VCC), U6.14 (VCC), U7.14 (VCC), U8.14 (VCC), U9.14 (VCC), U10.14 (VCC), U11.16 (VCC), U12.30 (CE2), U12.32 (VCC)
/A0: CE1.28 (A0), U2.12 (A0), U12.12 (A0)
/A1: CE1.27 (A1), U2.11 (A1), U12.11 (A1)
/A2: CE1.30 (A2), U2.10 (A2), U12.10 (A2)
/A3: CE1.29 (A3), U2.9 (A3), U12.9 (A3)
/A4: CE1.32 (A4), U2.8 (A4), U12.8 (A4)
/A5: CE1.31 (A5), U2.7 (A5), U12.7 (A5)
/A6: CE1.22 (A6), U2.6 (A6), U11.3 (A1), U12.6 (A6)
/A7: CE1.21 (A7), U2.5 (A7), U11.2 (A0), U12.5 (A7)
/A8: CE1.24 (A8), U2.27 (A8), U12.27 (A8)
/A9: CE1.17 (A9), U2.26 (A9), U12.26 (A9)
/A10: CE1.20 (A10), U2.23 (A10), U12.23 (A10)
/A11: CE1.19 (A11), U2.25 (A11), U12.25 (A11)
/A12: CE1.23 (A12), U2.4 (A12), U12.4 (A12)
/A13: CE1.26 (A13), U5.2 (1A), U6.2
/A15: CE1.18 (A15), U1.4 (Rb), U1.13 (Wb), U3.4 (Rb), U3.13 (Wb)
/D0: CE1.34 (D0), U1.3 (D4), U2.13 (D0), U12.13 (D0)
/D1: CE1.33 (D1), U1.2 (D3), U2.14 (D1), U12.14 (D1)
/D2: CE1.36 (D2), U1.1 (D2), U2.15 (D2), U12.15 (D2)
/D3: CE1.35 (D3), U1.15 (D1), U2.17 (D3), U12.17 (D3)
/D4: CE1.38 (D4), U2.18 (D4), U3.3 (D4), U7.1, U12.18 (D4)
/D5: CE1.37 (D5), U2.19 (D5), U3.2 (D3), U7.4, U12.19 (D5)
/D6: CE1.40 (D6), U2.20 (D6), U3.1 (D2), U7.9, U12.20 (D6)
/D7: CE1.39 (D7), U2.21 (D7), U3.15 (D1), U7.12, U12.21 (D7)
/MA13: U2.28 (A13), U5.4 (1Y), U12.28 (A13)
/MA14: U2.3 (A14), U5.7 (2Y), U12.3 (A14)
/MA15: U2.31 (A15), U5.9 (3Y), U12.31 (A15)
/MA16: U2.2 (A16), U5.12 (4Y), U12.2 (A16)
/MA17: U4.4 (1Y), U11.14 (A0)
/MA18: U4.7 (2Y)
/MA19: U4.9 (3Y)
/MA20: U4.12 (4Y)
/RAM_0: U2.22 (~CE1), U11.12 (O0)
/RAM_1: U11.11 (O1), U12.22 (~CE1)
/RW: U9.8
/SEL_A: U1.5 (Ra), U1.14 (Wa), U3.5 (Ra), U3.14 (Wa), U6.3
//16KSEL: U4.1 (S_/A), U5.1 (S_/A), U6.1, U8.8 (~Q)
//670WE: U1.12 (~Ew), U3.12 (~Ew), U9.6
//IORQ: CE1.11 (~IORQ), U11.1 (E)
//RD: CE1.14 (~RD), U2.24 (~OE), U10.2, U10.3, U12.24 (~OE)
//RESET: CE1.15 (~RESET), U6.5
//STLSL: CE1.4 (~STLSL), U9.4, U11.15 (E)
//WR: CE1.13 (~WR), U2.29 (~WE), U9.1, U12.29 (~WE)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, CE1.41 (GND), CE1.43 (GND), RN1.1 (common), RN2.1 (common), U1.8 (GND), U1.11 (~Er), U2.16 (GND), U3.8 (GND), U3.11 (~Er), U4.8 (GND), U4.15 (E), U5.8 (GND), U5.15 (E), U6.7 (GND), U7.7 (GND), U8.2 (D), U8.3 (C), U8.7 (GND), U8.11 (C), U8.12 (D), U9.7 (GND), U10.7 (GND), U11.8 (GND), U11.13 (A1), U12.16 (GND)
unnamed: RN1.2 (R1), U1.6 (Q4), U5.3 (1B), U5.5 (2A)
unnamed: RN1.3 (R2), U1.7 (Q3), U5.6 (2B), U5.11 (3A)
unnamed: RN1.4 (R3), U1.9 (Q2), U5.10 (3B), U5.14 (4A)
unnamed: RN1.5 (R4), U1.10 (Q1), U4.2 (1A), U5.13 (4B)
unnamed: RN2.2 (R1), U3.6 (Q4), U4.3 (1B)
unnamed: RN2.3 (R2), U3.7 (Q3), U4.5 (2A), U4.6 (2B)
unnamed: RN2.4 (R3), U3.9 (Q2), U4.10 (3B), U4.11 (3A)
unnamed: RN2.5 (R4), U3.10 (Q1), U4.13 (4B), U4.14 (4A)
unnamed: U6.4, U7.3
unnamed: U8.5 (Q), U9.2
unnamed: U8.6 (~Q), U9.9
unnamed: U7.6, U8.1 (~R)
unnamed: U6.6, U8.4 (~S)
unnamed: U7.11, U8.13 (~R)
unnamed: U7.8, U8.10 (~S)
unnamed: U9.3, U9.5
unnamed: U9.10, U10.1
unnamed: U7.2, U7.5, U7.10, U7.13, U11.4 (O0)

Notes on the sheet:
회로도 편집기

Board: 2 copper layers, 100.7 x 87.3 mm, 28 parts (0 on the bottom side), 58 nets.

## KiCad design project2_2/project2_2.kicad_pcb

Parts:
C1, C2, C3, C4, C6, C7, C8: 0.1uF; C_Disc_D6.0mm_W2.5mm_P5.00mm
C5: 10uF; CP_Radial_D5.0mm_P2.50mm
CE1: Card_Edge_Connector_MSX; card_edge_connector_MSX
J1, J3, J4: Conn_02x02; PinHeader_2x02_P2.54mm_Vertical
J2: Conn_02x03; PinHeader_2x03_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1, U2: AT27C020; PLCC-32_THT-Socket
U3, U4: 74LS670; DIP-16_W7.62mm_Socket
U5: 74LS32; DIP-14_W7.62mm_Socket
U6: 74LS00; DIP-14_W7.62mm_Socket
U7: 74LS139; DIP-16_W7.62mm_Socket

Connections:
+5V: C1.1, C2.1, C3.1, C4.2, C5.1, C6.1, C7.1, C8.1, CE1.45 (+5V), CE1.47 (+5V), U1.1 (VPP), U1.31 (~PGM), U1.32 (VCC), U2.1 (VPP), U2.31 (~PGM), U2.32 (VCC), U3.16 (VCC), U4.16 (VCC), U5.14 (VCC), U6.14 (VCC), U7.16 (VCC)
/A0: CE1.28 (A0), U1.12 (A0), U2.12 (A0)
/A1: CE1.27 (A1), U1.11 (A1), U2.11 (A1)
/A2: CE1.30 (A2), U1.10 (A2), U2.10 (A2)
/A3: CE1.29 (A3), U1.9 (A3), U2.9 (A3)
/A4: CE1.32 (A4), U1.8 (A4), U2.8 (A4)
/A5: CE1.31 (A5), U1.7 (A5), U2.7 (A5)
/A6: CE1.22 (A6), U1.6 (A6), U2.6 (A6)
/A7: CE1.21 (A7), U1.5 (A7), U2.5 (A7)
/A8: CE1.24 (A8), U1.27 (A8), U2.27 (A8)
/A9: CE1.17 (A9), U1.26 (A9), U2.26 (A9)
/A10: CE1.20 (A10), U1.23 (A10), U2.23 (A10)
/A11: CE1.19 (A11), J2.1, U1.25 (A11), U2.25 (A11)
/A12: CE1.23 (A12), J1.1, J2.3, U1.4 (A12), U2.4 (A12)
/A13: CE1.26 (A13), U1.28 (A13), U2.28 (A13), U6.1
/A14: CE1.25 (A14), U6.2
/A15: CE1.18 (A15), J3.1, J4.3, U5.9
/D0: CE1.34 (D0), U1.13 (D0), U2.13 (D0), U3.15 (D1)
/D1: CE1.33 (D1), U1.14 (D1), U2.14 (D1), U3.1 (D2)
/D2: CE1.36 (D2), U1.15 (D2), U2.15 (D2), U3.2 (D3)
/D3: CE1.35 (D3), U1.17 (D3), U2.17 (D3), U3.3 (D4)
/D4: CE1.38 (D4), U1.18 (D4), U2.18 (D4), U4.15 (D1)
/D5: CE1.37 (D5), U1.19 (D5), U2.19 (D5), U4.1 (D2)
/D6: CE1.40 (D6), U1.20 (D6), U2.20 (D6)
/D7: CE1.39 (D7), U1.21 (D7), U2.21 (D7)
/MA14: R4.2, U1.29 (A14), U2.29 (A14), U3.10 (Q1)
/MA15: R3.2, U1.3 (A15), U2.3 (A15), U3.9 (Q2)
/MA16: R2.2, U1.2 (A16), U2.2 (A16), U3.7 (Q3)
/MA17: R1.2, U1.30 (A17), U2.30 (A17), U3.6 (Q4)
/ROM_CE1: U1.22 (~CE), U7.4 (O0)
/ROM_CE2: U2.22 (~CE), U7.5 (O1)
//RD: CE1.14 (~RD), U1.24 (~OE), U2.24 (~OE)
//SLTSL: CE1.4 (~STLSL), U5.2, U7.1 (E)
//WR: CE1.13 (~WR), U5.1
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, CE1.41 (GND), CE1.43 (GND), J1.3, J2.5, J3.3, J4.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, U1.16 (GND), U2.16 (GND), U3.8 (GND), U3.11 (~Er), U4.2 (D3), U4.3 (D4), U4.8 (GND), U4.11 (~Er), U5.7 (GND), U6.7 (GND), U7.8 (GND)
unnamed: J1.2, J1.4, U3.14 (Wa), U4.14 (Wa)
unnamed: J2.2, J2.4, J2.6, U3.13 (Wb), U4.13 (Wb)
unnamed: J3.2, J3.4, U3.5 (Ra), U4.5 (Ra)
unnamed: J4.2, J4.4, U3.4 (Rb), U4.4 (Rb)
unnamed: U3.12 (~Ew), U4.12 (~Ew), U5.6
unnamed: R6.2, U4.10 (Q1), U7.2 (A0)
unnamed: R5.2, U4.9 (Q2), U7.3 (A1)
unnamed: U5.3, U5.5
unnamed: U5.4, U5.8
unnamed: U5.10, U6.3

Board: 2 copper layers, 100.7 x 64.0 mm, 26 parts (0 on the bottom side), 45 nets.
